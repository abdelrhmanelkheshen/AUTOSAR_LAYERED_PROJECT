<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FINAL_PROJECT.ewp</path>
    </project>
    <batchBuild />
</workspace>
